# Keil uVision project LED.uvprojx, settings and files
target STM32F103_FreeRTos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CS32F103C8 CKS
  pack: Keil.CS32F1xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\inc;..\HARDWARE;..\HARDWARE\HLW8110;..\HARDWARE\oled;..\HMAC\inc;..\MALLOC;..\MQTT;..\Project;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TFT;..\HARDWARE\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
    ../FreeRTOS/include/: FreeRTOS.h FreeRTOSConfig.h
    ../HARDWARE/: includes.h
  group HARDWARE
    ../HARDWARE/src/: Bsp.c encoder.c exti.c key.c led.c Control_Interrupt.c control.c openmv_data.c DS1302.c usart2.c Timer2.c
    ../HARDWARE/HLW8110/: HLW8110.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_spi.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group PORT
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Malloc
    ../MALLOC/: malloc.c
  group TFT
    ../TFT/: lcd.c GUI.c test.c touch.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group WIFI_MQTT
    ../MQTT/: mqtt.c MQTT_Control.c wifi.c timer.c usart3.c
